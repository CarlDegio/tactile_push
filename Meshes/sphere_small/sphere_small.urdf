Commit message: add push ball and control base on depth

File: Meshes/sphere_small/sphere_small.urdf (robot description, URDF)
Before this commit: robot sphere_small, 1 links, 0 joints
Links:
- link base_link: geometry collision sphere radius=0.03; visual sphere radius=0.03
